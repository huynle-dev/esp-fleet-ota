#include "fota_selfcheck.h"
#include <cstring>

namespace fota {

namespace {

// Throwaway KAT key (P-256 SPKI DER). In no trusted key table; it signs nothing but kMsg.
const uint8_t kKey[] = {
    0x30, 0x59, 0x30, 0x13, 0x06, 0x07, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x02, 0x01, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce,
    0x3d, 0x03, 0x01, 0x07, 0x03, 0x42, 0x00, 0x04, 0x1f, 0xa5, 0xcf, 0x27, 0x6f, 0xad, 0x67, 0xb1, 0x75, 0x22, 0xfe,
    0x14, 0x23, 0xea, 0xf9, 0x76, 0x49, 0x87, 0x8c, 0x9c, 0xe1, 0x58, 0xdc, 0xeb, 0xef, 0xe9, 0x84, 0x28, 0x91, 0xe5,
    0x42, 0x5f, 0xd6, 0xe9, 0x53, 0xac, 0x15, 0xea, 0x8e, 0xd6, 0x5c, 0xf9, 0x4f, 0xaf, 0xbf, 0xb3, 0x3f, 0xfd, 0x0b,
    0xe4, 0x1d, 0x52, 0xde, 0xf4, 0x1f, 0x72, 0x21, 0xa4, 0xfb, 0xdd, 0x06, 0xec, 0x1b, 0xd5};
const char kMsg[] = "esp-fleet-ota known-answer test v1";
const uint8_t kSig[] = {
    0x30, 0x45, 0x02, 0x20, 0x15, 0xf4, 0x01, 0xb5, 0xab, 0x21, 0x96, 0xff, 0xf9, 0xd9, 0xc8, 0xf1, 0xc2, 0x13, 0xbd,
    0x65, 0xc0, 0x29, 0x84, 0x67, 0xa3, 0x63, 0x32, 0x52, 0x00, 0x34, 0x14, 0x67, 0x3f, 0xad, 0x75, 0x48, 0x02, 0x21,
    0x00, 0x92, 0xad, 0xf1, 0x02, 0x91, 0xa2, 0x2d, 0x24, 0xf7, 0x20, 0x9c, 0xbe, 0x88, 0xcb, 0x8b, 0x29, 0xd8, 0xb9,
    0x38, 0xdf, 0x90, 0xfe, 0x7e, 0xd9, 0x33, 0xe5, 0x40, 0xe3, 0x15, 0x3f, 0xdb, 0xe1};
// FIPS 180-2 SHA-256("abc")
const uint8_t kAbc[32] = {0xba, 0x78, 0x16, 0xbf, 0x8f, 0x01, 0xcf, 0xea, 0x41, 0x41, 0x40, 0xde, 0x5d, 0xae, 0x22,
                          0x23, 0xb0, 0x03, 0x61, 0xa3, 0x96, 0x17, 0x7a, 0x9c, 0xb4, 0x10, 0xff, 0x61, 0xf2, 0x00,
                          0x15, 0xad};

void hash(ISha256& sha, const uint8_t* d, size_t n, uint8_t out[32]) {
    sha.begin();
    sha.update(d, n);
    sha.finish(out);
}

} // namespace

bool cryptoSelfCheck(ISha256& sha, IEcdsaP256Verifier& ecdsa) {
    uint8_t h[32];
    hash(sha, (const uint8_t*)"abc", 3, h);
    if (memcmp(h, kAbc, 32) != 0) return false;

    hash(sha, (const uint8_t*)kMsg, sizeof(kMsg) - 1, h);
    if (!ecdsa.verify(kKey, sizeof(kKey), h, kSig, sizeof(kSig))) return false;

    uint8_t bad[32];
    memcpy(bad, h, 32);
    bad[31] ^= 0x01;
    if (ecdsa.verify(kKey, sizeof(kKey), bad, kSig, sizeof(kSig))) return false;   // other message

    uint8_t sig[sizeof(kSig)];
    memcpy(sig, kSig, sizeof(sig));
    sig[10] ^= 0x01;
    if (ecdsa.verify(kKey, sizeof(kKey), h, sig, sizeof(sig))) return false;       // flipped signature
    if (ecdsa.verify(kKey, sizeof(kKey), h, kSig, sizeof(kSig) - 1)) return false; // truncated DER
    return true;
}

} // namespace fota
